options:
  parameters:
    generate_options: qt_gui
    id: lab3_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_stop
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '270000'
  states: {}
- name: eitbg
  id: variable_qtgui_chooser
  parameters:
    label0: 90.1 (rds)
    label1: 89.7 (rds)
    label2: 93.7 (rds)
    label3: '88.0'
    label4: '92.9'
    num_opts: '5'
    option0: '90100000'
    option1: '89700000'
    option2: '93700000'
    option3: '8800000'
    option4: '92900000'
    type: real
    value: '90100000'
  states: {state: disabled}
- name: f_central
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '90100000'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '150'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9600000'
  states: {}
- name: transition_band
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '2000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: int(samp_rate/200)
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate/20
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/200)
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/200)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\isvoropaev\Documents\eirhbg
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_stop
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_band
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: int(samp_rate/200)
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_central
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Input spec"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/40)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Demod output"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/200)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Demod output"'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: f_central
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0_0, '0']
- [analog_fm_deemph_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
