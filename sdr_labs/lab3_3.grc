options:
  parameters:
    generate_options: qt_gui
    id: lab3_3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_stop
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '270000'
  states: {}
- name: f_central
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '90100000'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '150'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
  states: {}
- name: transition_band
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '2000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '2100'
    gain: '1.0'
    samp_rate: int(samp_rate/20)
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '655360'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate/10
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '12'
    deemph_tau: '75e-6'
    quad_rate: samp_rate/10
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(samp_rate/120)
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.02'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 12000/(1187.5 * 2)
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '57000'
    decim: '2'
    samp_rate: samp_rate/20
    taps: variable_low_pass_filter_taps_0
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_stop
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_band
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '8'
    gain: '1'
    samp_rate: int(samp_rate/40)
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/(40*8)
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/20)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Demod output"'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: f_central
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '0', audio_sink_0_0_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0_0_0_0, '1']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_arg_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [digital_costas_loop_cc_0, '0', low_pass_filter_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0_0_1, '0', blocks_complex_to_arg_0, '0']
- [low_pass_filter_0_0_1, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
