options:
  parameters:
    generate_options: qt_gui
    id: lab3_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_stop
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '270000'
  states: {}
- name: eitbg
  id: variable_qtgui_chooser
  parameters:
    label0: 90.1 (rds)
    label1: 89.7 (rds)
    label2: 93.7 (rds)
    label3: '88.0'
    label4: '92.9'
    num_opts: '5'
    option0: '90100000'
    option1: '89700000'
    option2: '93700000'
    option3: '8800000'
    option4: '92900000'
    type: real
    value: '90100000'
  states: {state: disabled}
- name: f_central
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '90100000'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '150'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9600000'
  states: {}
- name: transition_band
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '2000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '2100'
    gain: '1.0'
    samp_rate: int(samp_rate/40)
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: int(samp_rate/200)
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: int(samp_rate/200)
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate/20
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: samp_rate/20
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/200)
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/200)
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(samp_rate/200)
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(samp_rate/200)
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19500'
    low_cutoff_freq: '18500'
    samp_rate: samp_rate/40
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate/40
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.02'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 20000/1187
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '57000'
    decim: '2'
    samp_rate: samp_rate/40
    taps: variable_low_pass_filter_taps_0
    type: fcf
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '18000'
    decim: '1'
    gain: '1'
    samp_rate: int(samp_rate/40)
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_stop
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_band
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: int(samp_rate/200)
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '18000'
    decim: '1'
    gain: '30'
    samp_rate: int(samp_rate/200)
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '6'
    gain: '1'
    samp_rate: int(samp_rate/80)
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate/40)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_central
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Input spec"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate/200)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: int(samp_rate/200)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: int(samp_rate/200)
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/(40*8)
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/40)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Demod output"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/200)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Demod output"'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: f_central
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_fm_deemph_0, '0', audio_sink_0_0, '0']
- [analog_fm_deemph_0, '0', blocks_add_xx_0, '0']
- [analog_fm_deemph_0, '0', blocks_sub_xx_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0_1, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0, '2']
- [analog_fm_deemph_0_0, '0', blocks_add_xx_0, '1']
- [analog_fm_deemph_0_0, '0', blocks_sub_xx_0, '1']
- [analog_fm_deemph_0_0, '0', qtgui_freq_sink_x_0_1, '1']
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0_0, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_pll_0, '0', audio_sink_0_0_0_0, '0']
- [analog_wfm_rcv_pll_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0_0_0_0, '1']
- [analog_wfm_rcv_pll_0, '1', qtgui_time_sink_x_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1_0, '1']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', high_pass_filter_0, '0']
- [blocks_multiply_xx_1_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_sub_xx_0, '0', audio_sink_0_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', low_pass_filter_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_xx_1_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '2']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0_0, '0', analog_fm_deemph_0, '0']
- [low_pass_filter_0_0_0, '0', analog_fm_deemph_0_0, '0']
- [low_pass_filter_0_0_1, '0', blocks_complex_to_arg_0, '0']
- [low_pass_filter_0_0_1, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
