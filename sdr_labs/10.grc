options:
  parameters:
    author: '79312'
    generate_options: qt_gui
    id: lab_rds
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_rx1
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '250000000'
  states: {}
- name: f_rx2
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '252000000'
  states: {}
- name: f_tx1
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '300000000'
  states: {}
- name: f_tx2
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '302000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '12'
    quad_rate: int(samp_rate/6)
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '12'
    deemph_tau: '75e-6'
    quad_rate: '384000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(samp_rate/(12*6))
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '270000'
    decim: '6'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_rx1
    fftsize: '1024'
    name: '"input"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/(12*6))
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: f_rx1
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0, '1']
- [low_pass_filter_1, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_pll_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
