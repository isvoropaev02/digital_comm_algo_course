options:
  parameters:
    generate_options: qt_gui
    id: lab1_7
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_pass
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '3500'
  states: {}
- name: audio_stop
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '5000'
  states: {}
- name: eitbg
  id: variable_qtgui_chooser
  parameters:
    label0: 90.1 (rds)
    label1: 89.7 (rds)
    label2: 93.7 (rds)
    label3: '88.0'
    label4: '92.9'
    num_opts: '5'
    option0: '90100000'
    option1: '89700000'
    option2: '93700000'
    option3: '8800000'
    option4: '92900000'
    type: real
    value: '90100000'
  states: {state: disabled}
- name: f_central
  id: variable
  parameters:
    value: '900000'
  states: {}
- name: f_station
  id: variable_qtgui_chooser
  parameters:
    label0: 880khz
    label1: 800khz
    label2: 750khz
    num_opts: '3'
    option0: '880000'
    option1: '800000'
    option2: '750000'
    type: real
    value: '880000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: transition_band
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '500'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: audio_pass
    audio_stop: audio_stop
    chan_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_station - f_central
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\isvoropaev\Desktop\gnu_rad\AM_center900k_sampling400k.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '12'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '12'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_stop
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_band
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_central
    fftsize: '2048'
    freqhalf: 'False'
    name: '"Input spec"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '32000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    name: '"Input spec"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '2'
    type: fff
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
